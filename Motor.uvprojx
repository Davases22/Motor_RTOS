# Keil uVision project Motor.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MaquetaSTM32 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: HSE_VALUE=8000000
  c include: ..\LIBRERIAS\Adc;..\LIBRERIAS\Bit;..\LIBRERIAS\Bus;..\LIBRERIAS\Captura;..\LIBRERIAS\Contador;..\LIBRERIAS\Dac;..\LIBRERIAS\Delay;..\LIBRERIAS\Dis7seg;..\LIBRERIAS\Dma;..\LIBRERIAS\Encoder;..\LIBRERIAS\Flash;..\LIBRERIAS\GLcd;..\LIBRERIAS\I2c;..\LIBRERIAS\Lcd;..\LIBRERIAS\Pin;..\LIBRERIAS\Port;..\LIBRERIAS\Pwm;..\LIBRERIAS\Reloj;..\LIBRERIAS\Spi;..\LIBRERIAS\Stm32f;..\LIBRERIAS\Teclado;..\LIBRERIAS\Usart;..\LIBRERIAS\Rtc;..\LIBRERIAS\Complejo;..\LIBRERIAS\Polinomio;..\LIBRERIAS\Fraccion;..\LIBRERIAS\Timer;..\LIBRERIAS\Sensores;..\LIBRERIAS\Esp8266;..\LIBRERIAS\PCF8574;..\LIBRERIAS\MatLab
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ../LIBRERIAS/Adc/: Adc.cpp Adc.h
    ../LIBRERIAS/Bus/: Bus.cpp Bus.h
    ../LIBRERIAS/Captura/: Captura.cpp Captura.h
    ../LIBRERIAS/Contador/: Contador.cpp Contador.h
    ../LIBRERIAS/Dac/: Dac.cpp Dac.h
    ../LIBRERIAS/Delay/: Delay.cpp Delay.h
    ../LIBRERIAS/Dis7seg/: Dis7Seg.cpp Dis7Seg.h
    ../LIBRERIAS/Dma/: Dma.cpp Dma.h
    ../LIBRERIAS/Encoder/: Encoder.cpp Encoder.h
    ../LIBRERIAS/Flash/: Flash.cpp Flash.h
    ../LIBRERIAS/GLcd/: FontTexto.h GLcd.cpp GLcd.h GLcd12864.cpp GLcd12864.h ILIGLcd.cpp ILIGLcd.h Nokia5110.cpp Nokia5110.h Sh1106.cpp Sh1106.h Ssd1306.cpp Ssd1306.h
    ../LIBRERIAS/I2c/: I2c.cpp I2c.h I2cBus.cpp I2cBus.h I2cSoft.cpp I2cSoft.h
    ../LIBRERIAS/Lcd/: Lcd.cpp Lcd.h
    ../LIBRERIAS/Port/: Port.cpp Port.h
    ../LIBRERIAS/Pwm/: Pwm.cpp Pwm.h
    ../LIBRERIAS/Reloj/: Reloj.cpp Reloj.h
    ../LIBRERIAS/Spi/: Spi.cpp Spi.h SpiBus.cpp SpiBus.h SpiSoft.cpp SpiSoft.h
    ../LIBRERIAS/Stm32f/: Stm32f.cpp Stm32f.h
    ../LIBRERIAS/Teclado/: Teclado.cpp Teclado.h
    ../LIBRERIAS/Usart/: Usart.cpp Usart.h
    ../LIBRERIAS/Bit/: Bit.cpp Bit.h
    ../LIBRERIAS/Pin/: Pin.cpp Pin.h
    ../LIBRERIAS/Rtc/: Rtc.cpp Rtc.h
    ../LIBRERIAS/Complejo/: Complejo.cpp Complejo.h
    ../LIBRERIAS/Timer/: Timer.cpp Timer.h
    ./: Main.cpp
    ../LIBRERIAS/Sensores/: Lm75.cpp Lm75.h Mpu6050.cpp Mpu6050.h Hcsr04.cpp Hcsr04.h Bmp180.cpp Bmp180.h Hmc5883.cpp Hmc5883.h Qmc5883.cpp Qmc5883.h Lsm9ds1.cpp Lsm9ds1.h
    ../LIBRERIAS/Esp8266/: Esp8266.cpp Esp8266.h
    ../LIBRERIAS/PCF8574/: PCF8574.cpp PCF8574.h
    ../LIBRERIAS/MatLab/: Control_Motor.cpp Control_Motor.h rtwtypes.h rtw_continuous.h rtw_solver.h
software components: CMSIS:CORE 6.1.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 2.6.3
